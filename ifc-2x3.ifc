Properties of the parts of a building model (IFC2X3)

# File
Description: Funk-Heizungsaktor, UP, Fernfühler optional, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: BA110201, Funk-Heizungsaktor, UP, Fernfühler optional
In: Raum
Description: Funkaktoren (Funk-Heizungsregler), die in Verbindung mit alre-Funk-Raumtemperatursensoren eine Einzelraum-Temperaturregelung verwirklichen. Anwendung überwiegend im Sanierungsbereich oder bei Heizungsanlagenerweiterungen. 1-Kanal Funk-Temperaturaktor, zur Ansteuerung einer (elektrischen) Fußbodenheizung verfügt der Regler über einen Sensoreingang, an dem ein optional erhältlicher Fernfühler angeschlossen werden kann, der in den Fußboden eingelassen wird, in Verbindung mit einem solchen Sensor sind folgende Betriebsmodi realisierbar: Funktion Fußbodenregelung oder Funktion Raumtemperaturregelung mit Fußbodenwächter mit direkter oder zentraler Sollwertvorgabe (Zentralregelung), wird auf den Fernfühler verzichtet, fungiert der HTFRU-110.124 als Raumtemperaturregler mit direkter oder zentraler Sollwertvorgabe (Zentralregelung).; Classification: EC000436 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: BA110201; ModelLabel: HTFRU-110.124; GlobalTradeItemNumber: 4050528015068; ProductURL: https://alre.de/produkt_BA110201
Pset_Specification - NominalLength: 0.0645 m; NominalWidth: 0.0594 m; NominalDepth: 0.0345 m; NetWeight: 0.074
Pset_ALRE_ETIM_Properties - Montageart: Unterputz; Farbe: weiß; Stromversorgung: 230 V AC; Anzahl der Relais: 1; Werkstoffgüte: Thermoplast; Werkstoff: Kunststoff; Funkfrequenz: 868; RAL-Nummer (ähnlich): 9010; Ausführung der Oberfläche: matt; Geeignet für Schutzart (IP): IP20; ETIM-Klasse: EC000436; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-BA110201.pdf
